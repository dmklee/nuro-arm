Commit message: cube size will now be changed with globalScalingg

File: neu_ro_arm/assets/urdf/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base_link: mass 1 -> 0.1; geometry collision box size=1 1 1; visual box size=1 1 1

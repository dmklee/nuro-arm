Commit message: camera is now added to motion planner

File: neu_ro_arm/src/assets/xarm.urdf (robot description, URDF)
Before this commit: robot xArm, 9 links, 8 joints
Joints:
- joint world_joint: origin xyz=0.0 0.0 0.012 rpy=0.0 0.0 0.0 -> xyz=0.0 0.0 0.012 rpy=0.0 0.0 1.5708

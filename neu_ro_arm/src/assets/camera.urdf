Commit message: update

File: neu_ro_arm/src/assets/camera.urdf (robot description, URDF)
Before this commit: robot Camera, 2 links, 1 joints
Joints:
- joint world_joint: origin xyz=0.0 -0.013 -0.012 rpy=0 1.5708 -1.5708 -> xyz=0.0 -0.013 -0.013 rpy=0 1.5708 -1.5708
